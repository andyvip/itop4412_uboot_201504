## board/samsung/itop-4412/Kconfig
```kconfig
if TARGET_ITOP-4412

config SYS_BOARD
	default "itop-4412"

config SYS_VENDOR
	default "samsung"

config SYS_CONFIG_NAME
	default "itop-4412"

endif
```
